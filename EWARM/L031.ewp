# IAR project L031.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L031xx; USE_STM32L0XX_NUCLEO_32; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Libraries\STM32L0xx_HAL_Driver\Inc; ..\Libraries\CMSIS\Device\ST\STM32L0xx\Include; ..\User\Main; ..\User\App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L031.hex
  ILINK.IlinkOutputFile: L031.out
  ILINK.IlinkIcfFile: C:\Users\T460P\Desktop\STM32L031\code\stm32L_uart\Libraries\CMSIS\Device\ST\STM32L0xx\Source\Templates\iar\linker\stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Hal_Driver
    ../User/App/: bsp_uart_fifo.c
    ../Libraries/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Main
    ../User/Main/: main.c stm32l0xx_it.c stm32l0xx_nucleo_32.c system_stm32l0xx.c
    ../Libraries/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l031xx.s
